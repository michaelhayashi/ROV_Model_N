# IAR project Backup of ROV.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F4XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Libraries\STM32F4xx_StdPeriph_Driver\inc; Libraries\CMSIS\ST\STM32F4xx\Include; Libraries\CMSIS\ST\STM32F4xx\; ; ..\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ROV.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Chip Files
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_it.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
    Libraries/CMSIS/ST/STM32F4xx/Include/: stm32f4xx.h
    ./: stm32f4xx_conf.h
    Libraries/CMSIS/ST/STM32F4xx/Source/: system_stm32f4xx.c
  group User
    ./: abstract.h functions.c functions.h main.c
